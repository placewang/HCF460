# Keil uVision project inout.uvprojx, settings and files
target spi_four_wire_tx_and_rx_interrupt_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.9
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: G294 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __DEBUG,HC32F46x,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;D:\keilpacks\ARM\CMSIS\5.8.0\CMSIS\Core\Include;..\modbus_port;..\modbus
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x60000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f46x.s
    ../../../../mcu/common/: system_hc32f46x.c
  group source
    ../source/: main.c upgrade.c logic_lay.c message.c machconfig.c mot.c tmc5610.c board_g294.c motordemand.c motordemand_b.c SignalReturn.c
  group driver
    ../../../../driver/src/: hc32f46x_utility.c hc32f46x_clk.c hc32f46x_efm.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_interrupts.c hc32f46x_pwc.c hc32f46x_timer0.c hc32f46x_can.c hc32f46x_usart.c hc32f46x_timera.c hc32f46x_spi.c
target spi_four_wire_tx_and_rx_interrupt_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.9
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: spi_four_wire_tx_and_rx_interrupt +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --keep=*Handler
